v {xschem version=3.4.6RC file_version=1.2
}
G {}
K {}
V {}
S {}
E {}
C {ipin.sym} -120 -40 0 0 {name=p0 lab=VGND}
C {ipin.sym} -120 -20 0 0 {name=p1 lab=VPB}
C {ipin.sym} -120 0 0 0 {name=p2 lab=VPWR}
